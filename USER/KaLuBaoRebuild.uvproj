# Keil uVision project KaLuBaoRebuild.uvproj, settings and files
target Project (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: KaLuBaoRebuild +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\OBD;..\SYSTEM;..\USER;..\LIB\inc;..\UCOSII\CONFIG;..\UCOSII\PORT;..\UCOSII\CORE;..\HAEDWARE;..\GPS;..\CDMA;..\DEAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group GPS
    ../GPS/: GPSTask.c GPSConfig.c GPS_Tx_Rx.c
  group CDMA
    ../CDMA/: CDMATask.c CDMA_Tx_Rx.c CDMA_OTA_TASK.c CDMAConfigTask.c
  group OBD
    ../OBD/: OBDTask.c OBDCAN_Tx_Rx.c caninformationlib.c OBDKLineTxRx.c
  group DEAL
    ../DEAL/: memBlock.c memQ.c memStore.c crcCompute.c varDeal.c
  group HARDWARE
    ../HAEDWARE/: bsp.c CANConfig.c time_systick.c
  group CORE
    ../CORE/: core_cm3.c
    ./: startup_stm32f10x_hd.s
  group LIB
    ../LIB/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_tim.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu_a.asm os_cpu_c.c os_cpu.h
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group README
    ./: Readme.txt
