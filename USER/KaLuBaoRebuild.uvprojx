# Keil uVision project KaLuBaoRebuild.uvprojx, settings and files
target Project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: KaLuBaoRebuild +hex
  AfterMake: $KARM\BIN\ELFDWT.EXE       "#L"     BASEADDRESS(0x8008000)
  AfterMake: $KARM\ARMCC\BIN\fromelf.exe      --bin     --bincombined      --output      "#L.bin"     "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\OBD;..\SYSTEM;..\USER;..\LIB\inc;..\UCOSII\CONFIG;..\UCOSII\PORT;..\UCOSII\CORE;..\HAEDWARE;..\GPS;..\CDMA;..\DEAL;..\USB\CONFIG;..\USB\STM32_USB-FS-Device_Driver\inc;..\CORE
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x2e000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c powerDeal.c normalTask.c stm32f10x_it.c system_stm32f10x.c
  group CDMA
    ../CDMA/: CDMATask.c CDMARecvTask.c CDMA_Tx_Rx.c DataSaveToFlash.c
  group OBD
    ../OBD/: OBDTask.c CAN_J1939.c OBDCAN_Tx_Rx.c caninformationlib.c OBDKLineTxRx.c
    ../HAEDWARE/: CANConfig.c
  group DEAL
    ../DEAL/: memBlock.c memQ.c memStore.c crcCompute.c varDeal.c
  group USB
    ../USB/: USBTask.c
    ../USB/CONFIG/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
    ../USB/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group GPS
    ../GPS/: GPSTask.c GPSConfig.c GPS_Tx_Rx.c
  group HARDWARE
    ../HAEDWARE/: bsp.c time_systick.c
  group CORE
    ../CORE/: core_cm3.c
    ./: startup_stm32f10x_hd.s
  group LIB
    ../LIB/src/: misc.c stm32f10x_dbgmcu.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_pwr.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu_a.asm os_cpu_c.c os_cpu.h
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group README
    ./: Readme.txt
software components: CMSIS:CORE 5.0.1
